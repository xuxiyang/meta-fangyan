RDEPENDS_${PN} += " \
     tslib-dev \
     ncurses-dev \
     ncurses-staticdev \
     initfs-dev \
     initfs-staticdev \
     gtest-dev \
     gtest-staticdev \
"
