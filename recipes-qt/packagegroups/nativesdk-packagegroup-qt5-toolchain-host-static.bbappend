RDEPENDS_${PN} += " \
    nativesdk-packimg \
    nativesdk-squashfs-tools \
"
