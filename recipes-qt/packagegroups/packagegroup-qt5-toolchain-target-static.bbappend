RDEPENDS_${PN} += " \
    initfs-dev \
    initfs-staticdev \
    gtest-dev \
    gtest-staticdev \
"
